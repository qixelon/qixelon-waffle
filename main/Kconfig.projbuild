## main/Kconfig.projbuild
```kconfig
menu "Qixelon Waffle"

config WIFI_HOSTNAME
    string "Wifi Hostname"
    default "Qixelon"
    help
        DHCP hostname

endmenu
```
